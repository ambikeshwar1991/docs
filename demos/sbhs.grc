<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vector</key><value>40</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>setpoint</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>setpoint</value></param>
<param><key>value</key><value>37</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_sbhs</key>
<param><key>id</key><value>gr_sbhs_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>window</key><value>1</value></param>
</block>
<block>
<key>sbhs_controller</key>
<param><key>id</key><value>sbhs_controller_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>a</key><value>1</value></param>
<param><key>P</key><value>2</value></param>
<param><key>I</key><value>1</value></param>
<param><key>d</key><value>1</value></param>
<param><key>b</key><value>setpoint</value></param>
<param><key>window</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>grex_subtract</key>
<param><key>id</key><value>grex_subtract_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>preload</key><value>1</value></param>
</block>
<connection><source_block_id>sbhs_controller_0</source_block_id><sink_block_id>gr_sbhs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0</source_block_id><sink_block_id>gr_sbhs_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>grex_subtract_0</source_block_id><sink_block_id>sbhs_controller_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sbhs_0</source_block_id><sink_block_id>grex_subtract_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>grex_subtract_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sbhs_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
